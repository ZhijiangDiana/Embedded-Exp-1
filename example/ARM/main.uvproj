# Keil uVision project main.uvproj, settings and files
target MB9BF50x Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MB9BF500R Fujitsu Microelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0003FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: KSK_MB9BF506
  c include: ..\..\uCOS_II_V286\Source;..\..\uCOS_II_V286\CPU\ARM;..\source\modules;..\source\board;..\source\picture;..\..\common;..\source\main
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./: startup_MB9BF50x.s
  group Source Files
    ./: Serial.c Retarget.c
    ../source/main/: main.c
    ../../common/: system_mb9bf50x.c
  group Documentation
    ./: Abstract.txt
  group ucos2
    ../../uCOS_II_V286/Source/: os_tmr.c os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
    ../../uCOS_II_V286/CPU/ARM/: os_cpu_c.c os_cpu_a.s
  group modules
    ../source/modules/: lcd.c adc.c key.c
target MB9BF50x RAM (ARM-ADS)
  device: MB9BF500R FUJITSU MICROELECTRONICS
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000

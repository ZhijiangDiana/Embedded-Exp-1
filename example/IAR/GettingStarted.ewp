# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: KSK_MB9BF506
  ICCARM.CCIncludePath2: board\; modules\; picture\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MB9BF506_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  ICCARM.CCIncludePath2: ..\board\; ..\modules\; ..\main\; ..\driver\; ..\picture\; ..\..\common\; ..\..\uCOS_II_V286\CPU\IAR\; ..\..\uCOS_II_V286\Source\
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\mb9bf506.icf
  group common
    ../../common/: core_cm3.c system_mb9bf50x.c
  group driver/adc
    ../source/driver/adc/: adc12_FM3.c
  group driver/bt
    ../source/driver/bt/: bt_fm3.c
  group driver/clock
    ../source/driver/clock/: clock_fm3.c
  group driver/cr
    ../source/driver/cr/: cr_fm3.c
  group driver/crc
    ../source/driver/crc/: crc_fm3.c
  group driver/cs
    ../source/driver/cs/: csv_fm3.c
  group driver/dmac
    ../source/driver/dmac/: dmac_fm3.c
  group driver/dt
    ../source/driver/dt/: dt_fm3.c
  group driver/extint
    ../source/driver/extint/: extint_fm3.c
  group driver/io
    ../source/driver/io/: io_fm3.c
  group driver/lpcm
    ../source/driver/lpcm/: lpcm_fm3.c
  group driver/lvd
    ../source/driver/lvd/: lvd_fm3.c
  group driver/mfs
    ../source/driver/mfs/: mfs_fm3.c
  group driver/mfs/csio
    ../source/driver/mfs/csio/: csio_fm3.c
  group driver/mfs/i2c
    ../source/driver/mfs/i2c/: i2c_fm3.c
  group driver/mfs/lin
    ../source/driver/mfs/lin/: lin_fm3.c
  group driver/mfs/uart
    ../source/driver/mfs/uart/: uart_fm3.c
  group driver/mft
    ../source/driver/mft/: mft_adcmp_fm3.c mft_frt_fm3.c mft_icu_fm3.c mft_ocu_fm3.c mft_wfg_fm3.c
  group driver/qprc
    ../source/driver/qprc/: qprc_fm3.c
  group driver/wc
    ../source/driver/wc/: wc_fm3.c
  group driver/wd
    ../source/driver/wd/: wd_fm3.c
  group modules
    ../source/modules/: adc.c key.c lcd.c
  group startup
    ./: cstartup_M.s
  group ucos2
    ../../uCOS_II_V286/Source/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../uCOS_II_V286/CPU/IAR/: os_cpu_a.asm os_cpu_c.c
  group user
    ../source/main/: main.c uart.c
